Commit message: robot6 urdf has been update thanks to moveit

File: urdf/robot6.urdf (robot description, URDF)
Before this commit: robot m2wr, 10 links, 9 joints
Joints:
- joint arm_joint_02: axis 1 0 0 -> 0 0 1
- joint arm_joint_03: axis -1 0 0 -> 0 0 1
